## server/sdkconfig.defaults
```kconfig
CONFIG_LIBC_NEWLIB=y
CONFIG_ESP_MAIN_TASK_STACK_SIZE=8196
CONFIG_VFS_SUPPORT_TERMIOS=y
```
